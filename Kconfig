## Kconfig
```kconfig
menu "euart"
	config EUART_BUFFSIZE
		int "EUART buffer size"
        default 2048 
	
endmenu
```
